# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HTTP_Server +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\RTE\Log;.\RTE\userFiles
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x20020000 size 0x1000
  memory RVCT9: RAM 0x20021000 size 0x5f000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
    ./RTE/userFiles/: ThreadDisplayHandler.c ThreadDisplayHandler.h ThreadUserEth.c ThreadUserEth.h
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif
  group Documentation
    ./: Abstract.txt
  group LcdLogger
    ./RTE/Log/: lcd_log.c lcd_log.h lcd_log_conf.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: HTTP_Server
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Network:CORE 7.12.0, Network:CORE 7.12.0, Network:Interface:ETH 7.12.0, Network:Service:Web Server Compact 7.12.0, Network:Socket:TCP 7.12.0, Network:Socket:UDP 7.12.0, Board Support:Buttons 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:LCD 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:LED 1.1.0, CMSIS Driver:Ethernet MAC 1.8.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:ADC 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:DMA2D 1.2.7, Device:STM32Cube HAL:DSI 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:I2C 1.2.7, Device:STM32Cube HAL:LTDC 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:SDRAM 1.2.7, Device:STM32Cube HAL:SRAM 1.2.7, Device:Startup 1.2.4
